# Keil uVision project WtApplication.uvproj, settings and files
target 8051 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: WtApplication +hex
  c flags: Optimize=8 SizeSpeed=1
  group Program
    ./: WtApplication.c WtApplication.h test.c Conf_tny.A51 WtApplicationWait.a51 Overlay.lin
